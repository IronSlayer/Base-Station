<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bladeRF_transceiver</value></param>
<param><key>author</key><value>Renzo Chan Rios</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>bladeRF_transceiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>access_code</value></param>
<param><key>value</key><value>'11010011100100011101001110010001'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bandwith</value></param>
<param><key>value</key><value>1.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>float(symbole_rate*bit_per_sym)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bit_per_sym</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>demod_selector</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation</value></param>
<param><key>value</key><value>20e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>firdes_cuttoff</value></param>
<param><key>value</key><value>21e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>firdes_decim</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>firdes_filter</value></param>
<param><key>value</key><value>firdes.low_pass(1,samp_rate/2, firdes_cuttoff, firdes_transition_width)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>firdes_transition_width</value></param>
<param><key>value</key><value>15000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency_rx</value></param>
<param><key>value</key><value>450e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency_rx_final</value></param>
<param><key>value</key><value>frequency_rx-frequency_shift</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency_shift</value></param>
<param><key>value</key><value>520000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency_tx</value></param>
<param><key>value</key><value>450e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod_selector</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulation_index</value></param>
<param><key>value</key><value>float(deviation/(baud_rate/2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>msg_sink_msgq_out</value></param>
<param><key>value</key><value>gr.msg_queue(10)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>msg_source_msgq_in</value></param>
<param><key>value</key><value>gr.msg_queue(1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>'0101010101010101'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rat_decim</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rat_interop</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_bb_gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_rf_gain</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_valve_gfsk_value</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_valve_gmsk_value</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>int(samp_rate / symbole_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym_source</value></param>
<param><key>value</key><value>((samp_rate/2/firdes_decim)*rat_interop/rat_decim) / symbole_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sensitivity</value></param>
<param><key>value</key><value>float((math.pi*modulation_index)/samp_per_sym)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbole_rate</value></param>
<param><key>value</key><value>31.25e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_bb_gain</value></param>
<param><key>value</key><value>-20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_rf_gain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_valve_gfsk_value</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_valve_gmsk_value</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>binary_slicer</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>binary_slicer_0</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>mod_selector</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0</value></param>
<param><key>input_index</key><value>demod_selector</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>cc1111_cc1111_packet_decoder</key>
<param><key>id</key><value>cc1111_packet_decoder</value></param>
<param><key>do_crc16_check</key><value>True</value></param>
<param><key>drop_header</key><value>True</value></param>
<param><key>target_queue</key><value>msg_sink_msgq_out</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>do_unwhitening</key><value>True</value></param>
</block>
<block>
<key>cc1111_cc1111_packet_encoder</key>
<param><key>id</key><value>cc1111_packet_encoder</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>add_crc</key><value>True</value></param>
<param><key>bits_per_symbol</key><value>bit_per_sym</value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>preamble</key><value>preamble</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>source_queue</key><value>msg_source_msgq_in</value></param>
<param><key>do_whitening</key><value>True</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>clock_recovery</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samp_per_sym_source*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>clock_recovery_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samp_per_sym_source*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_correlate_access_code_bb</key>
<param><key>id</key><value>correlate_access_code</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>threshold</key><value>4</value></param>
</block>
<block>
<key>digital_dxpsk_demod</key>
<param><key>id</key><value>digital_dxpsk_demod_0</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>freq_bw</key><value>6.28/100.0</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>log</key><value>False</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>sync_out</key><value>False</value></param>
<param><key>timing_bw</key><value>6.28/100.0</value></param>
<param><key>type</key><value>dbpsk</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>digital_dxpsk_mod</key>
<param><key>id</key><value>digital_dxpsk_mod_0</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>log</key><value>False</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>type</key><value>dbpsk</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>digital_gfsk_mod</key>
<param><key>id</key><value>gfsk_mod</value></param>
<param><key>bt</key><value>0.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>sensitivity</key><value>sensitivity</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>gmsk_mod</value></param>
<param><key>bt</key><value>0.350</value></param>
<param><key>samples_per_symbol</key><value>int(samp_per_sym)</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>nlog10_ff</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink</value></param>
<param><key>bb_gain0</key><value>tx_bb_gain</value></param>
<param><key>bw0</key><value>bandwith</value></param>
<param><key>freq0</key><value>frequency_tx</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>gain0</key><value>tx_rf_gain</value></param>
<param><key>args</key><value>bladerf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source</value></param>
<param><key>bb_gain0</key><value>rx_bb_gain</value></param>
<param><key>bw0</key><value>bandwith</value></param>
<param><key>freq0</key><value>frequency_rx_final</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>rx_rf_gain</value></param>
<param><key>args</key><value>bladerf=0,fpga=/home/pi/hostedx40.rbf</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe_signal_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>quadrature_demod</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0/sensitivity</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>quadrature_demod_0</value></param>
<param><key>gain</key><value>2</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_0</value></param>
<param><key>decim</key><value>rat_decim</value></param>
<param><key>interp</key><value>rat_interop</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_0_0</value></param>
<param><key>decim</key><value>rat_decim</value></param>
<param><key>interp</key><value>rat_interop</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_valve_gfsk</value></param>
<param><key>open</key><value>rx_valve_gfsk_value</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>rx_valve_gmsk</value></param>
<param><key>open</key><value>rx_valve_gmsk_value</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate/2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate/2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>tx_valve_gfsk</value></param>
<param><key>open</key><value>tx_valve_gfsk_value</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>tx_valve_gmsk</value></param>
<param><key>open</key><value>tx_valve_gmsk_value</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>xlating_fir_filter_0_0</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>firdes_decim</value></param>
<param><key>samp_rate</key><value>samp_rate/2</value></param>
<param><key>taps</key><value>firdes_filter</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>xlating_fir_filter_0_0_0</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>firdes_decim</value></param>
<param><key>samp_rate</key><value>samp_rate/2</value></param>
<param><key>taps</key><value>firdes_filter</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>xlating_fir_filter_1_0</value></param>
<param><key>center_freq</key><value>frequency_shift</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>xlating_fir_filter_1_0_0</value></param>
<param><key>center_freq</key><value>frequency_shift</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>binary_slicer</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>binary_slicer_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>osmosdr_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>correlate_access_code</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cc1111_packet_decoder</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cc1111_packet_encoder</source_block_id><sink_block_id>digital_dxpsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cc1111_packet_encoder</source_block_id><sink_block_id>gfsk_mod</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cc1111_packet_encoder</source_block_id><sink_block_id>gmsk_mod</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>clock_recovery</source_block_id><sink_block_id>binary_slicer</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>clock_recovery_0</source_block_id><sink_block_id>binary_slicer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correlate_access_code</source_block_id><sink_block_id>cc1111_packet_decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_dxpsk_demod_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_dxpsk_mod_0</source_block_id><sink_block_id>tx_valve_gfsk</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>nlog10_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfsk_mod</source_block_id><sink_block_id>tx_valve_gfsk</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gmsk_mod</source_block_id><sink_block_id>tx_valve_gmsk</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nlog10_ff</source_block_id><sink_block_id>probe_signal_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source</source_block_id><sink_block_id>rx_valve_gfsk</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source</source_block_id><sink_block_id>rx_valve_gmsk</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>quadrature_demod</source_block_id><sink_block_id>clock_recovery</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>quadrature_demod_0</source_block_id><sink_block_id>clock_recovery_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_0</source_block_id><sink_block_id>digital_dxpsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_0</source_block_id><sink_block_id>quadrature_demod</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_0_0</source_block_id><sink_block_id>quadrature_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_valve_gfsk</source_block_id><sink_block_id>xlating_fir_filter_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_valve_gmsk</source_block_id><sink_block_id>xlating_fir_filter_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>throttle_0</source_block_id><sink_block_id>xlating_fir_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>throttle_0_0</source_block_id><sink_block_id>xlating_fir_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tx_valve_gfsk</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>tx_valve_gmsk</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter_0_0</source_block_id><sink_block_id>rational_resampler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter_0_0_0</source_block_id><sink_block_id>rational_resampler_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter_1_0</source_block_id><sink_block_id>throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter_1_0_0</source_block_id><sink_block_id>throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
